# Keil uVision project iSO-STM32.uvprojx, settings and files
target os__stm32 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ucosii +hex
  c flags: Optim=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\APP;..\..\BSP;..\..\ucosII\Ports;..\..\ucosII\Source;..\..\BSP\BlueTooth;..\..\BSP\Delay;..\..\BSP\GPS;..\..\BSP\HMC5883L;..\..\BSP\I2cdev;..\..\BSP\Motor;..\..\BSP\MPU6050;..\..\BSP\MS5611;..\..\BSP\Receiver;..\..\BSP\TIM7;..\..\BSP\Usart;..\..\APP\CONTROL;..\..\APP\IMU;..\..\BSP\eeprom
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group DOC
    ../../Doc/: readme.txt
  group BSP
    ../../BSP/: BSP.c bsp_led.c
    ../../BSP/BlueTooth/: BlueTooth.c
    ../../BSP/GPS/: GPS.c
    ../../BSP/Motor/: motor.c
    ../../BSP/Receiver/: Rev.c
    ../../BSP/TIM7/: tim7.c
    ../../BSP/Usart/: usart1.c
    ../../BSP/MPU6050/: MPU6050.c IMU.c
    ../../BSP/eeprom/: eeprom.c flash.c
    ../../BSP/I2cdev/: I2cdev.c
  group APP
    ../../APP/: app.c
  group UCOSII/SOURCES
    ../../ucosII/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII/PROTS
    ../../ucosII/Ports/: os_cpu_c.c os_dbg.c os_cpu_a.asm
  group APP_BLUETOOTH
    ../../APP/BLUETOOTH/: appBluetooth.c
  group APP_CONTROL
    ../../APP/CONTROL/: control.c controlPID.c
  group APP_IMU
    ../../APP/IMU/: APP_IMU.c
